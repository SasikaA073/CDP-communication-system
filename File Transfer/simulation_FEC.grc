options:
  parameters:
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: '12000'
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: '12000'
    ndim: '0'
    rep: '3'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '520834'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: trans_freq
  id: variable
  parameters:
    value: 2.46e9
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/thisara/Downloads/CDP-communication-system/File Transfer/output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thisara/Downloads/CDP-communication-system/File Transfer/message.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '12'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: cc
  states: {}
- name: fec_extended_tagged_decoder_2
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: dec_rep
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0_1
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: enc_rep
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '30'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Transmit"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Receive"'
    type: complex
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 500e3
    center_freq: trans_freq
    gain: '66'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 500e3
    center_freq: trans_freq
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [blocks_char_to_float_1_1, '0', fec_extended_tagged_decoder_2, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_0_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_gfsk_mod_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', digital_map_bb_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_1_0, '0']
- [digital_crc32_bb_0_1, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_1, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [fec_extended_tagged_decoder_2, '0', blocks_repack_bits_bb_1_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', fec_extended_tagged_encoder_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
