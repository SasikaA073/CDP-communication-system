options:
  parameters:
    generate_options: qt_gui
    id: audio_player
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/sasika/Documents/Com_design_project/CDP-communication-system/GFSK/output.wav
    repeat: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
