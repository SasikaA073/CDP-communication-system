options:
  parameters:
    generate_options: qt_gui
    id: receiveronly
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '520834'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: trans_freq
  id: variable
  parameters:
    value: 2.46e9
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/thisara/Documents/GFSK/output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/thisara/Documents/GFSK/output.png
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/thisara/Documents/GFSK/output.wav
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/thisara/Documents/GFSK/output.tmp
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key_0
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Receive"'
    type: complex
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 500e3
    center_freq: trans_freq
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0_1, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0_1_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0_1_0_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
